Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: HiveWoodMini.blend.ifc
Time: 2023-04-13T16:04:14+03:00
Written by: IfcOpenShell v0.7.0-476ab506d
Made in: BlenderBIM 0.0.230304
Authorization: Nobody

# IfcActuator (469)
PredefinedType: ELECTRICACTUATOR
Name
66 x 1
67 x 2
67 x 3
70 x 4
65 x 5
69 x 6
64 x 7
H1008A01obj
